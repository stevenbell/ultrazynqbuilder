SRC_URI_append ="\
    file://system-user.dtsi \
    file://system-user-overlay.dtsi \
"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
